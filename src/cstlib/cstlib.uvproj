# Keil uVision project cstlib.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: cstlib (library)
  c flags: Optimize=8 SizeSpeed=1
  group led
    ./: led.h led.c
  group cstfx
    ./: cstfx.h cstfx.c
  group a_first
    ./: STARTUP.A51
